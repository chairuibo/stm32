# Keil uVision project Lab_project.uvprojx, settings and files
target project v1.0 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Lab_project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Core;..\ST_driver;..\ST_driver\inc;..\app;..\Core\startup;..\user_driver\usart;..\user_driver\delay;..\app\System_interrupt;..\user_driver\tim4;..\user_driver\motor;..\user_driver\usart2;..\user_driver\OLED;..\user_driver\allFunctions;..\user_driver\key;..\user_driver\iic_driver;..\user_driver\usart3;..\app\MiGong;..\user_driver\iic_driver;..\user_driver\can;..\user_driver\Bsp_rcc;..\user_driver\tim3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../app/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../app/System_interrupt/: System_interrupt.c
  group user_driver
    ../user_driver/delay/: delay.c
    ../user_driver/usart/: usart.c
    ../user_driver/can/: can1.c
    ../user_driver/key/: key.c
    ../user_driver/Bsp_rcc/: Bsp_Rcc.c
    ../user_driver/tim3/: timer3.c
  group Core
    ../Core/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group st_driver
    ../ST_driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_sdio.c stm32f10x_wwdg.c
  group start_up
    ../Core/startup/: startup_stm32f10x_md.s
